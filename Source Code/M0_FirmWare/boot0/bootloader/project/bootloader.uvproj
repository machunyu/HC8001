# Keil uVision project bootloader.uvproj, settings and files
target bootloader (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.1.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ../output/bootloader.bin ../output/bootloader.axf
  c flags: Optim=1 wLevel=2
  c include: ..\driver
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x2001a000 size 0x6000
  group startup
    ../startup/: startup_hs100.s system_iris.c
  group user
    ../user/: main.c
